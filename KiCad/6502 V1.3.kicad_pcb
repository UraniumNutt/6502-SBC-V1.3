# Repository UraniumNutt/6502-SBC-V1.3

File README.md:

This is a 6502 SBC I made. 
It is inspired by the YouTube series by Ben Eater. 
I made similar version before this, but I thought I could do better before sharing the design. 
My goal was to make a compact, simple computer with a serial port, and a uart usb bridge built in.
I also exposed the system bus, so it should be possible to create expansion cards which are mapped into memory.

## KiCad design KiCad/6502 V1.3.kicad_pcb

File KiCad/README.md:

This is a 6502 SBC I made. 
It is inspired by the YouTube series by Ben Eater. 
I made similar version before this, but I thought I could do better before sharing the design. 
My goal was to make a compact, simple computer with a serial port, and a uart usb bridge built in.
I also exposed the system bus, so it should be possible to create expansion cards which are mapped into memory.

Board: 2 copper layers, 152.4 x 76.2 mm, 41 parts (0 on the bottom side), 83 nets.

Parts:
C1, C2, C3, C4, C5, C6: 100 nF; C_1206_3216Metric
C7, C9: 47 pF; C_1206_3216Metric
C8: 10 uF; C_1206_3216Metric
C10: 10 nF; C_1206_3216Metric
D1: LED_{Rx}; LED_1206_3216Metric
D2: LED_{Tx}; LED_1206_3216Metric
D3: PWR; LED_1206_3216Metric
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J2: Conn_02x32_Odd_Even; PinSocket_2x32_P2.54mm_Vertical
JP1, JP2, JP3: Jumper_2_Bridged; PinHeader_1x02_P2.54mm_Vertical
R1, R3, R5, R10: 1000; R_1206_3216Metric
R2, R6: 5100; R_1206_3216Metric
R4, R8: 27; R_1206_3216Metric
R7, R9: 270; R_1206_3216Metric
RN1: R_Pack04; R_Array_Convex_4x1206
RN2: 1000; R_Array_Convex_4x1206
SW1: SW_DIP_x04; SW_DIP_SPSTx04_Slide_6.7x11.72mm_W8.61mm_P2.54mm_LowProfile
SW2: SW_Push; SW_SPST_EVQPE1
U1: W65C02SxP; DIP-40_W15.24mm
U2: W65C22SxP; DIP-40_W15.24mm
U3: W65C51NxP; DIP-28_W15.24mm
U4: CY62256-70PC; DIP-28_W15.24mm
U5: ATF22V10B-15GM/883; DIP-24_W7.62mm_Socket
U6: FT230XS; SSOP-16_3.9x4.9mm_P0.635mm
U7: SST39SF040; DIP-32_W15.24mm
X1: ACO-1MHz-A; Oscillator_DIP-14
X2: ACO-1.8432MHz-A; Oscillator_DIP-14

Connections:
A_{0}: J2.1, U1.9 (A0), U2.38 (RS0), U3.13 (RS0), U4.10 (A0), U7.12 (A0)
A_{1}: J2.3, U1.10 (A1), U2.37 (RS1), U3.14 (RS1), U4.9 (A1), U7.11 (A1)
A_{2}: J2.5, U1.11 (A2), U2.36 (RS2), U4.8 (A2), U7.10 (A2)
A_{3}: J2.7, U1.12 (A3), U2.35 (RS3), U4.7 (A3), U7.9 (A3)
A_{4}: J2.9, U1.13 (A4), U4.6 (A4), U5.22 (I/O), U7.8 (A4)
A_{5}: J2.11, U1.14 (A5), U4.5 (A5), U5.23 (I/O), U7.7 (A5)
A_{6}: J2.13, U1.15 (A6), U4.4 (A6), U5.11 (IN), U7.6 (A6)
A_{7}: J2.15, U1.16 (A7), U4.3 (A7), U5.10 (IN), U7.5 (A7)
A_{8}: J2.17, U1.17 (A8), U4.25 (A8), U5.9 (IN), U7.27 (A8)
A_{9}: J2.19, U1.18 (A9), U4.24 (A9), U5.8 (IN), U7.26 (A9)
A_{10}: J2.21, U1.19 (A10), U4.21 (A10), U5.7 (IN), U7.23 (A10)
A_{11}: J2.23, U1.20 (A11), U4.23 (A11), U5.6 (IN), U7.25 (A11)
A_{12}: J2.25, U1.22 (A12), U4.2 (A12), U5.5 (IN), U7.4 (A12)
A_{13}: J2.27, U1.23 (A13), U4.26 (A13), U5.4 (IN), U7.28 (A13)
A_{14}: J2.29, U1.24 (A14), U4.1 (A14), U5.3 (IN), U7.29 (A14)
A_{15}: J2.31, U1.25 (A15), U5.2 (IN)
BS_{0}: RN1.8 (R1.2), SW1.8, U7.3 (A15)
BS_{1}: RN1.7 (R2.2), SW1.7, U7.2 (A16)
BS_{2}: RN1.6 (R3.2), SW1.6, U7.30 (A17)
BS_{3}: RN1.5 (R4.2), SW1.5, U7.1 (A18)
CA_{1}: J2.32, U2.40 (CA1)
CA_{2}: J2.34, U2.39 (CA2)
CB_{1}: J2.56, U2.18 (CB1)
CB_{2}: J2.58, U2.19 (CB2)
CLK: J2.59, U1.37 (ϕ0), U2.25 (ϕ2), U3.27 (ϕ2), U5.1 (CLK/IN), X1.8 (OUT)
CLK_UART: U3.5 (RxC), U3.6 (XTAL1), X2.8 (OUT)
D_{0}: J2.33, U1.33 (D0), U2.33 (D0), U3.18 (D0), U4.11 (Q0), U7.13 (D0)
D_{1}: J2.35, U1.32 (D1), U2.32 (D1), U3.19 (D1), U4.12 (Q1), U7.14 (D1)
D_{2}: J2.37, U1.31 (D2), U2.31 (D2), U3.20 (D2), U4.13 (Q2), U7.15 (D2)
D_{3}: J2.39, U1.30 (D3), U2.30 (D3), U3.21 (D3), U4.15 (Q3), U7.17 (D3)
D_{4}: J2.41, U1.29 (D4), U2.29 (D4), U3.22 (D4), U4.16 (Q4), U7.18 (D4)
D_{5}: J2.43, U1.28 (D5), U2.28 (D5), U3.23 (D5), U4.17 (Q5), U7.19 (D5)
D_{6}: J2.45, U1.27 (D6), U2.27 (D6), U3.24 (D6), U4.18 (Q6), U7.20 (D6)
D_{7}: J2.47, U1.26 (D7), U2.26 (D7), U3.25 (D7), U4.19 (Q7), U7.21 (D7)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.2, C10.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.36, J2.60, J2.61, R2.2, R5.1, R6.2, R10.2, RN1.1 (R1.1), RN1.2 (R2.1), RN1.3 (R3.1), RN1.4 (R4.1), SW2.1, U1.21 (VSS), U2.1 (VSS), U3.1 (VSS), U3.16 (~DCD), U3.17 (~DSR), U4.14 (GND), U4.22 (~OE), U5.12 (GND), U6.5 (GND), U6.13 (GND), U7.16 (GND), U7.22 (CE), X1.7 (GND), X2.7 (GND)
INH: J2.49, R10.1, U5.13 (IN)
unnamed: D3.1 (K), R5.2
unnamed: D2.2 (A), R7.2
unnamed: D2.1 (K), U6.7 (CBUS2)
unnamed: D1.2 (A), R9.2
unnamed: D1.1 (K), U6.14 (CBUS1)
unnamed: J1.A5 (CC1), R6.1
unnamed: J1.A8 (SBU1), R2.1
unnamed: JP1.2 (B), RN2.8 (R1.2), U5.15 (I/O)
unnamed: JP2.2 (B), RN2.7 (R2.2), U5.16 (I/O)
unnamed: JP3.2 (B), RN2.6 (R3.2), U5.17 (I/O)
unnamed: R1.2, U1.2 (RDY)
unnamed: R7.1, R9.1, U6.3 (VCCIO), U6.10 (3V3OUT)
PA_{0}: J2.16, U2.2 (PA0)
PA_{1}: J2.18, U2.3 (PA1)
PA_{2}: J2.20, U2.4 (PA2)
PA_{3}: J2.22, U2.5 (PA3)
PA_{4}: J2.24, U2.6 (PA4)
PA_{5}: J2.26, U2.7 (PA5)
PA_{6}: J2.28, U2.8 (PA6)
PA_{7}: J2.30, U2.9 (PA7)
PB_{0}: J2.40, U2.10 (PB0)
PB_{1}: J2.42, U2.11 (PB1)
PB_{2}: J2.44, U2.12 (PB2)
PB_{3}: J2.46, U2.13 (PB3)
PB_{4}: J2.48, U2.14 (PB4)
PB_{5}: J2.50, U2.15 (PB5)
PB_{6}: J2.52, U2.16 (PB6)
PB_{7}: J2.54, U2.17 (PB7)
PUSBD+: C9.1, J1.A6 (D+), J1.B6 (D+), R8.1
PUSBD-: C7.1, J1.A7 (D-), J1.B7 (D-), R4.1
RxD: U3.12 (RxD), U6.1 (TXD)
R/~W: J2.2, U1.34 (R/~W), U2.22 (R/~W), U3.28 (R/~W), U4.27 (~WE)
TxD: U3.10 (TxD), U6.4 (RXD)
USBD+: R8.2, U6.8 (USBDP)
USBD-: R4.2, U6.9 (USBDM)
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C10.1, D3.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J2.38, J2.62, J2.63, R1.1, R3.2, RN2.1 (R1.1), RN2.2 (R2.1), RN2.3 (R3.1), RN2.4 (R4.1), SW1.1, SW1.2, SW1.3, SW1.4, U1.6 (~NMI), U1.8 (VDD), U1.36 (BE), U2.20 (VCC), U2.24 (CS1), U3.2 (CS1), U3.15 (VCC), U4.28 (VCC), U5.24 (VCC), U6.11 (~RESET), U6.12 (VCC), U7.31 (PGM), U7.32 (VCC), X1.14 (Vcc), X2.14 (Vcc)
~ACIACS: J2.57, U3.3 (~CS2), U5.18 (I/O)
~CTS: U3.9 (~CTS), U6.2 (~RTS)
~IRQ_{ACIA}: JP2.1 (A), U3.26 (~IRQ)
~IRQ_{CPU}: U1.4 (~IRQ), U5.14 (I/O)
~IRQ_{PORT}: J2.64, JP3.1 (A)
~IRQ_{VIA}: JP1.1 (A), U2.21 (~IRQ)
~RAMCS: J2.53, U4.20 (~CS), U5.20 (I/O)
~ROMOE: J2.51, U5.21 (I/O), U7.24 (OE)
~RST: C8.2, R3.1, SW2.2, U1.40 (~RES), U2.34 (~RES), U3.4 (~RES)
~RTS: U3.8 (~RTS), U6.6 (~CTS)
~VIACS: J2.55, U2.23 (~CS2), U5.19 (I/O)

## Commit log

2024-01-19 init
2024-01-20 Designed board
2024-01-20 More routing
2024-01-22 More tracing1
2024-01-22 Finished routing
2024-01-22 Fixed round traces
2024-01-23 Finished tracing, corrected INH pull resistor
2024-01-23 Added board image
2024-01-30 Fixed 22V10 Socket size, added makefile, created example code
2024-06-09 code: Developed math routines, debugged address decoding files
2024-06-09 Removed rounded versions
